require qt5-git.inc
require ${PN}.inc

QT_MODULE_BRANCH = "master"

# last tag before this SRCREV is 5.0.0-beta1, but version says 5.3.0 already
SRCREV = "5bc5eaf6886bd8187746ef8b29bacb1263c6178a"
