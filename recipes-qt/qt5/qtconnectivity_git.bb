require qt5-git.inc
require ${BPN}.inc

SRCREV = "08e2153a216a4f2cd4ec71a2013031e4d2d12197"
