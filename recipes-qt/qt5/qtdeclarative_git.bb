require qt5-git.inc
require ${PN}.inc

SRCREV = "ebbabba0a57e756b846ff49c74f3ce1f6acf6824"
