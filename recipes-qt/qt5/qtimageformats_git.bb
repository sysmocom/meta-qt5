require qt5-git.inc
require ${PN}.inc

SRCREV = "554d617762c86964dfa074074304993ccdfbe2c9"
