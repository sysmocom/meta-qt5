require qt5-git.inc
require ${PN}.inc

SRCREV = "a13d8e8862402a144ace00e409341185783927df"
