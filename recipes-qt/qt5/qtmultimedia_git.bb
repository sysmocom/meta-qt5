require qt5-git.inc
require ${PN}.inc

SRCREV = "19ce431f9feec52327d902ab7005db5aff655535"
