require qt5-git.inc
require ${PN}.inc

SRCREV = "9aac83d22ddbebc22fb1360d710263d349c2fdda"
