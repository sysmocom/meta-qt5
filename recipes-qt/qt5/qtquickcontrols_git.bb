require qt5-git.inc
require ${PN}.inc

SRCREV = "241ffae4518159caa812d594c2702ac16e0c8f29"
