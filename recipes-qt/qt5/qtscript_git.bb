require qt5-git.inc
require ${PN}.inc

SRCREV = "08d9ef715265d33f4cf04693b0787fd75994dc42"
