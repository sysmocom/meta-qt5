require qt5-git.inc
require ${PN}.inc

SRCREV = "14293dcb7002b185b49ec1ad802055eee63f2473"
