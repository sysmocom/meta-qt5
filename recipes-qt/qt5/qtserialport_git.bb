require qt5-git.inc
require ${PN}.inc

SRCREV = "33bd1e08d0043e9b1340898039562bdf595879b5"
