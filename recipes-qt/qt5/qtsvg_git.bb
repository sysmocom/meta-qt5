require qt5-git.inc
require ${PN}.inc

SRCREV = "2fde61964d8f7300476dbde2e8e17fb5a54dbf40"
