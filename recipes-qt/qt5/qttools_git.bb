require qt5-git.inc
require ${PN}.inc

SRCREV = "167cb8f63095c655e6897b544ee9776aae009a23"
