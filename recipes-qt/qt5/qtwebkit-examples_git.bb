require qt5-git.inc
require ${PN}.inc

SRCREV = "3dbc1ad633490a84888c18f455359c4c62d29330"
