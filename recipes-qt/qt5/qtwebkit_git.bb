require qt5-git.inc
require ${PN}.inc

SRCREV = "fef642ef67e2dd8d44dcf4ec175d9613910aa78f"
