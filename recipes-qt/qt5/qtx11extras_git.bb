require qt5-git.inc
require ${PN}.inc

SRCREV = "01754de4776905205d38d7bc66fa7b7caa0fe79b"
