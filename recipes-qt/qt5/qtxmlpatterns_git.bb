require qt5-git.inc
require ${PN}.inc

SRCREV = "e14e55a6d222346f3d4a27c310913ed0742c3e6b"
